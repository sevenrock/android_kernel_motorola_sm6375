## drivers/fm/Kconfig
```kconfig
config RADIO_ELNA
	tristate "ELNA FM Radio"
	help
	Choose Y here if you have this FM radio chip.
```
